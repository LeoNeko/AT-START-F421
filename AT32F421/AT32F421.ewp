# IAR project AT32F421.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F421C8T7_v2 ArteryTek -AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1
  ICCARM.CCIncludePath2: BSP\Src; Core\Src; Drivers\AT32F421_HAL_Driver\Inc; BSP\Inc; Core\Inc; Drivers\AT32F421_HAL_Driver\Inc; Middlewares\FreeRTOS\source\include; D:\Projects\AT32F421\Middlewares\FreeRTOS\source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AT32F421.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group BSP/Inc
    BSP/Inc/: at32f421_board.h
  group BSP/Src
    BSP/Src/: at32f421_board.c
  group Core/Inc
    Core/Inc/: at32f421_clock.h at32f421_conf.h at32f421_int.h FreeRTOSConfig.h
  group Core/Src
    Core/Src/: at32f421_clock.c at32f421_int.c
  group Drivers/AT32F421_HAL_Driver/Inc
    Drivers/AT32F421_HAL_Driver/Inc/: at32f421_adc.h at32f421_cmp.h at32f421_crc.h at32f421_crm.h at32f421_debug.h at32f421_def.h at32f421_dma.h at32f421_ertc.h at32f421_exint.h at32f421_flash.h at32f421_gpio.h at32f421_i2c.h at32f421_misc.h at32f421_pwc.h at32f421_scfg.h at32f421_spi.h at32f421_tmr.h at32f421_usart.h at32f421_wdt.h at32f421_wwdt.h
  group Drivers/AT32F421_HAL_Driver/Src
    Drivers/AT32F421_HAL_Driver/Src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group Drivers/CMSIS/cm4/core_support
    Drivers/CMSIS/cm4/core_support/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h mpu_armv8.h pmu_armv8.h
  group Drivers/CMSIS/cm4/device_support
    Drivers/CMSIS/cm4/device_support/: at32f421.h at32f421_conf_template.h system_at32f421.c system_at32f421.h
  group Drivers/CMSIS/cm4/device_support/startup/iar
    Drivers/CMSIS/cm4/device_support/startup/iar/: startup_at32f421.s
  group Drivers/CMSIS/cm4/device_support/startup/iar/linker
    Drivers/CMSIS/cm4/device_support/startup/iar/linker/: AT32F421x4.icf AT32F421x6.icf AT32F421x8.icf
  group Middlewares/FatFs
    Middlewares/FatFs/: LICENSE.txt
  group Middlewares/FatFs/source
    Middlewares/FatFs/source/: 00history.txt 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h ffconf_template.h ffsystem.c ffunicode.c
  group Middlewares/FreeRTOS
    Middlewares/FreeRTOS/: readme.txt
  group Middlewares/FreeRTOS/license
    Middlewares/FreeRTOS/license/: license.txt
  group Middlewares/FreeRTOS/source
    Middlewares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/source/include
    Middlewares/FreeRTOS/source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
